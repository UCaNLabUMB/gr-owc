options:
  parameters:
    author: UCan_Lab
    description: Transmits Packets over RF with B200Mini
    generate_options: qt_gui
    id: RF_Packet_Error_Rate
    output_language: python
    title: RF_Packet_Error_Testing
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: packet_len
  states: {}
- name: oc_high
  id: variable
  parameters:
    value: (-4,-3,3,4)
  states: {}
- name: oc_low
  id: variable
  parameters:
    value: (-3,3)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: path_select
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: oc_high
    option1: oc_low
    type: raw
    value: oc_high
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: range(0,20)
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: path_select
    packet_len_key: packet_len
    payload_mod: '"QPSK"'
    pilot_carriers: (-6,-5,5,6)
    pilot_symbols: (-1,1,-1,1)
    rolloff: '0'
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
