options:
  parameters:
    author: ucanlab
    generate_options: qt_gui
    id: Multi_Node_Rx_Remote_02
    output_language: python
    title: Multi-Node Receiver with Remote Control
  states: {}

blocks:
- name: f_cut_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Cutoff Frequency - Filter 1
    orient: Qt.Horizontal
    start: 5e5
    step: 2.5e5
    stop: samp_rate/2
    value: 1e6
  states: {}
- name: f_cut_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,3,1,1
    label: Cutoff Frequency - Filter 2
    orient: Qt.Horizontal
    start: 5e5
    step: 2.5e5
    stop: samp_rate/2
    value: 5e5
  states: {}
- name: n_avg
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: select_filter_1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Filter 1
    label0: Bypass
    label1: Enable
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: select_filter_2
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,2,1,1
    label: Filter 2
    label0: Bypass
    label1: Enable
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: n_avg
    max_iter: '10000'
    scale: 1000/n_avg
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: n_avg
    max_iter: '10000'
    scale: 1000/n_avg
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: select_filter_2
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: select_filter_1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cut_2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cut_1
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,2
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 4,0,1,2
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 5,0,3,4
    name: '"Channel 2"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,3,4
    name: '"Channel 1"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,1
    name: '"Channel 1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Channel 2"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: AB
    ant1: AB
    ant2: AB
    center_freq0: '0'
    center_freq1: '0'
    center_freq2: '0'
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dc_offs_enb2: '""'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    gain2: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    iq_imbal_enb2: '""'
    nchan: '3'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    rx_agc2: Default
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Sig_1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Sig_0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Sig_0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Sig_1
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 10.1.1.3
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.1.1.3:55555
    hwm: '1'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://10.1.1.3:55556
    hwm: '1'
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_selector_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_selector_0_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '1']
- [low_pass_filter_0_0, '0', blocks_selector_0_0, '1']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '2', qtgui_waterfall_sink_x_0_1, '0']
- [uhd_usrp_source_0, '2', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_selector_0_0, '0']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0_0, '0', blocks_selector_0, '0']
- [virtual_source_0_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
