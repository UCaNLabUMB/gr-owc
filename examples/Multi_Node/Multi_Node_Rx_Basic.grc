options:
  parameters:
    author: ucanlab
    generate_options: qt_gui
    id: Multi_Node_Rx_Basic
    output_language: python
    title: Basic Multi-Node Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Channel 2"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,1
    name: '"Channel 1"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,1
    name: '"Channel 1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Channel 2"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: AB
    ant1: AB
    ant2: AB
    center_freq0: '0'
    center_freq1: '0'
    center_freq2: '0'
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dc_offs_enb2: '""'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    gain2: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    iq_imbal_enb2: '""'
    nchan: '3'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    rx_agc2: Default
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '2', blocks_complex_to_real_0_0, '0']
- [uhd_usrp_source_0, '2', qtgui_waterfall_sink_x_0_1, '0']

metadata:
  file_format: 1
