options:
  parameters:
    author: ucanlab
    generate_options: qt_gui
    id: Multi_Node_Rx_Basic
    output_language: python
    title: Basic Multi-Node Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Channel 2"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,1
    name: '"Channel 1"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,1
    name: '"Channel 1"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Channel 2"'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: AB
    ant1: AB
    ant2: AB
    center_freq0: '0'
    center_freq1: '0'
    center_freq2: '0'
    dev_args: '""'
    gain0: '0'
    gain1: '0'
    gain2: '0'
    nchan: '3'
    rx_agc2: Default
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '2', blocks_complex_to_real_0_0, '0']
- [uhd_usrp_source_0, '2', qtgui_waterfall_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
