options:
  parameters:
    generate_options: no_gui
    id: Prediction_VLP_Live
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: ad2_AD2_AnalogIn_Record_f_0
  id: ad2_AD2_AnalogIn_Record_f
  parameters:
    channel: '0'
    hz_acq: samp_rate
    n_samples: '16384'
    v_range: '5'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter1_high
    low_cutoff_freq: filter1_low
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter2_high
    low_cutoff_freq: filter2_low
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20000'
    max_iter: '4000'
    scale: 1/20000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '20000'
    max_iter: '4000'
    scale: 1/20000
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, min_power_threshold=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Prediction Block',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.min_power_threshold = min_power_threshold

              
          def work(self, input_items, output_items):
              in_buf0 = input_items[0]
              in_buf1 = input_items[1]
              
              for i in range(len(in_buf0)):
                  powers = np.array([in_buf0[i], in_buf1[i]])
                  if np.max(powers) < self.min_power_threshold:
                      output_items[0][i] = -1
                  else:
                      output_items[0][i] = float(np.argmax(powers))
                  
              return len(output_items[0])
    min_power_threshold: '1e-8'
  states: {}
- name: filter1_high
  id: parameter
  parameters:
    label: 1st Filter High Cutoff
    short_id: z
    type: eng_float
    value: 51e3
  states: {}
- name: filter1_low
  id: parameter
  parameters:
    label: 1st Filter Low Cutoff
    short_id: x
    type: eng_float
    value: 48e3
  states: {}
- name: filter2_high
  id: parameter
  parameters:
    label: 2nd Filter High Cutoff
    short_id: u
    type: eng_float
    value: 101e3
  states: {}
- name: filter2_low
  id: parameter
  parameters:
    label: 2nd Filter Low Cutoff
    short_id: y
    type: eng_float
    value: 98e3
  states: {}
- name: node_id
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '182'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: a
    type: eng_float
    value: '300000'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: '''10.1.1.'' + node_id'
    port: '8081'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '''tcp://10.1.1.'' +node_id+ '':55555'''
    timeout: '100'
    type: float
  states: {}

connections:
- [ad2_AD2_AnalogIn_Record_f_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0_0, '0', epy_block_0, '1']
- [blocks_throttle_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
