options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: OWC_SimpleTone
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ad2_AD2_AnalogOut_Sine_i_0
  id: ad2_AD2_AnalogOut_Sine_i
  parameters:
    amplituide: adb_amp
    channel: '0'
    offset: '1'
  states: {}
- name: adb_amp
  id: parameter
  parameters:
    label: Analog Discovery Board Ampltiude
    short_id: A
    type: intx
    value: '5'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: sig_freq
    type: int
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: node
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '182'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: a
    type: eng_float
    value: '300000'
  states: {}
- name: sig_freq
  id: parameter
  parameters:
    label: Signal Frequency
    short_id: f
    type: intx
    value: '1000'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: '"10.1.1." + node'
    port: '8080'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ad2_AD2_AnalogOut_Sine_i_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
