options:
  parameters:
    generate_options: no_gui
    id: OWC_RandomSignal
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: ad2_AD2_AnalogOut_Play_f_0
  id: ad2_AD2_AnalogOut_Play_f
  parameters:
    amplituide: adb_amp
    channel: '0'
    n_samples: buffer_size
    rate: samp_rate
  states: {}
- name: adb_amp
  id: parameter
  parameters:
    label: adb amp
    short_id: b
    type: eng_float
    value: '0'
  states: {}
- name: amp
  id: parameter
  parameters:
    label: amp
    short_id: A
    type: eng_float
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer Size
    short_id: z
    type: intx
    value: '32768'
  states: {}
- name: node
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '182'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: a
    type: eng_float
    value: '250000'
  states: {}
- name: tone_freq
  id: parameter
  parameters:
    label: freq
    short_id: f
    type: eng_float
    value: '0'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: '"10.1.1." + node'
    port: '8080'
  states: {}

connections:
- [analog_sig_source_x_0, '0', ad2_AD2_AnalogOut_Play_f_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
