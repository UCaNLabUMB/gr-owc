options:
  parameters:
    generate_options: qt_gui
    id: OWC_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ad2_AD2_AnalogIn_Record_f_0
  id: ad2_AD2_AnalogIn_Record_f
  parameters:
    channel: '0'
    hz_acq: samp_rate
    n_samples: '32768'
    v_range: '5'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: a
    type: eng_float
    value: '300000'
  states: {}

connections:
- [ad2_AD2_AnalogIn_Record_f_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
