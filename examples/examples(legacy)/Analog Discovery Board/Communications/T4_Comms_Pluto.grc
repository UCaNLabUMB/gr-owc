options:
  parameters:
    author: Jack Nguyen
    generate_options: no_gui
    id: T4_Comms_Pluto
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: CP_len
  id: variable
  parameters:
    value: fft_len//4
  states: {}
- name: carrier_list
  id: variable
  parameters:
    value: (list(range(-12, -2)))
  states: {}
- name: carrier_list_rf
  id: variable
  parameters:
    value: (list(range(-7, -2)) + list(range(3, 8)))
  states: {}
- name: fc
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: header_ph
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, 1, len_tag_key, "frame_"+len_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: len_tag_key_rf
  id: variable
  parameters:
    value: '"packet_len_rf"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (carrier_list,)
  states: {}
- name: occupied_carriers_rf
  id: variable
  parameters:
    value: ((carrier_list_rf),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '9'
  states: {}
- name: packet_len_rf
  id: variable
  parameters:
    value: '96'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-28, -1),)
  states: {}
- name: pilot_carriers_rf
  id: variable
  parameters:
    value: ((-10,-2,2,10),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((-1, 1),)
  states: {}
- name: pilot_syms_rf
  id: variable
  parameters:
    value: ((-1,1,-1,1),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: selector
  id: variable
  parameters:
    value: '0'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: variable_pb
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.035'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: len_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: len_tag_key
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: selector
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (499640,720,499640)
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: (len_tag_key)
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: (len_tag_key)
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: trigger
    target: variable_pb
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: len_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: len_tag_key
    packed: 'True'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: len_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: len_tag_key
    occupied_carriers: occupied_carriers_rf
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers_rf
    pilot_symbols: pilot_syms_rf
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: CP_len
    input_size: fft_len
    rolloff: rolloff
    tagname: len_tag_key
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: CP_len
    input_size: fft_len
    rolloff: rolloff
    tagname: len_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_ph
    len_tag_key: len_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_ph
    len_tag_key: len_tag_key
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr
      import sys
      sys.path.append("/home/ucanlab/WF_ADB/WaveForms-SDK-Getting-Started-PY-master")
      from ad_burst_tx import ADBurstTX

      class blk(gr.sync_block):
          def __init__(self,
                       samp_rate=250000,
                       amplitude=1.0,
                       len_tag_key="packet_len"):
              gr.sync_block.__init__(
                  self,
                  name="AD OFDM Burst Sink",
                  in_sig=[np.float32],
                  out_sig=None
              )

              self.len_tag_key = pmt.intern(len_tag_key)
              self.samp_rate = float(samp_rate)
              self.amplitude = float(amplitude)

              self.collecting = False
              self.expected_len = 0
              self.buffer = []

              self.tx = None

          def start(self):
              print("Opening AD device...")
              self.tx = ADBurstTX(channel=0)
              self.tx.open()
              self.tx.configure(
                  sample_rate=self.samp_rate,
                  amplitude=self.amplitude,
                  offset=0.0
              )
              return True

          def work(self, input_items, output_items):
              in0 = input_items[0]
              nread = self.nitems_read(0)

              if self.tx is None:
                  return len(in0)

              tags = self.get_tags_in_window(0, 0, len(in0))
              start_idx = 0

              for tag in tags:
                  if pmt.equal(tag.key, self.len_tag_key):
                      rel = int(tag.offset - nread)

                      if rel < 0 or rel >= len(in0):
                          continue

                      self.collecting = True
                      self.expected_len = int(pmt.to_long(tag.value))
                      self.buffer = []

                      take = min(len(in0) - rel, self.expected_len)
                      if take > 0:
                          self.buffer.extend(in0[rel:rel + take].tolist())

                      start_idx = rel + take
                      #print("Found packet_len tag:", self.expected_len)
                      break

              if self.collecting and len(self.buffer) < self.expected_len:
                  remaining = self.expected_len - len(self.buffer)
                  if start_idx < len(in0):
                      take = min(len(in0) - start_idx, remaining)
                      self.buffer.extend(in0[start_idx:start_idx + take].tolist())

              if self.collecting and len(self.buffer) >= self.expected_len:
                  burst = np.array(self.buffer[:self.expected_len], dtype=np.float64)

                  #print("Transmitting OFDM burst with", len(burst), "samples")
                  #print("burst min =", np.min(burst),
                  #      "max =", np.max(burst),
                  #      "peak =", np.max(np.abs(burst)))

                  # optional safety normalization only if needed
                  peak = np.max(np.abs(burst))
                  if peak > 1.0:
                      burst = burst / peak
                      #print("Normalized burst to +/-1")

                  self.tx.send_once(burst)

                  self.collecting = False
                  self.expected_len = 0
                  self.buffer = []

              return len(in0)

          def stop(self):
              if self.tx is not None:
                  try:
                      self.tx.close()
                  except Exception as e:
                      print("Close error:", e)
                  self.tx = None
              return True
    amplitude: '1'
    len_tag_key: len_tag_key
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import time

      # EDIT THIS PATH
      FILENAME = "/home/ucanlab/Downloads/test.txt"

      # If True, re-read the file every time you trigger
      RELOAD_ON_TRIGGER = False


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="trigger_send_file",
                  in_sig=None,
                  out_sig=None,
              )

              self.filename = FILENAME
              self.reload_on_trigger = RELOAD_ON_TRIGGER

              # Trigger input
              self.message_port_register_in(pmt.intern("trigger"))
              self.set_msg_handler(pmt.intern("trigger"), self.handle_trigger)

              # Output PDU
              self.message_port_register_out(pmt.intern("out"))

              self._tx_count = 0
              self._payload_bytes = b""

              # Load file once at start
              self._load_file()

          def _load_file(self):
              try:
                  with open(self.filename, "rb") as f:
                      self._payload_bytes = f.read()

                  if len(self._payload_bytes) == 0:
                      print(f"[WARN] Loaded '{self.filename}' but it is empty.")
                  else:
                      print(f"Loaded '{self.filename}' ({len(self._payload_bytes)} bytes)")

              except Exception as e:
                  self._payload_bytes = b""
                  print(f"[ERROR] Could not load '{self.filename}': {e}")

          def handle_trigger(self, msg):
              # Extract trigger value cleanly
              value_pmt = pmt.cdr(msg) if pmt.is_pair(msg) else msg
              try:
                  value = pmt.to_python(value_pmt)
              except:
                  print("Invalid TRIGGER PMT:", msg)
                  return

              # Only fire on real trigger
              if value != 1:
                  return

              # Reload file if desired
              if self.reload_on_trigger:
                  self._load_file()

              if not self._payload_bytes:
                  print("Triggered, but file is empty or not loaded.")
                  return

              # Metadata generated ONLY on trigger
              meta = pmt.make_dict()

              timestamp_str = time.strftime("%Y-%m-%d %H:%M:%S", time.localtime())
              meta = pmt.dict_add(meta, pmt.intern("timestamp"), pmt.intern(timestamp_str))

              self._tx_count += 1
              meta = pmt.dict_add(meta, pmt.intern("tx_count"), pmt.from_long(self._tx_count))

              # Payload: file bytes
              data = pmt.init_u8vector(len(self._payload_bytes), list(self._payload_bytes))

              # Publish PDU
              self.message_port_pub(pmt.intern("out"), pmt.cons(meta, data))

              print(f"Triggered -> sent '{self.filename}' (tx_count={self._tx_count})")

          def stop(self):
              return True
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '20000000'
    buffer_size: '1000000'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '915000000'
    samplerate: '1000000'
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: node_id
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '182'
  states: {}
- name: note_0
  id: note
  parameters:
    note: OWC OFDM Tx
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: RF OFDM Tx
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: OFDM Params
  states: {}
- name: owc_Hermitian_Symmetry_i_o_same_vec_size_cplus_0
  id: owc_Hermitian_Symmetry_i_o_same_vec_size_cplus
  parameters:
    fft_len: fft_len
    use_negative_coefficients: 'False'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_tag_key
    type: byte
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: OFDM Tx OWC
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: OFDM Tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Header_OWC
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Header_RF
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Payload_OWC
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: Payload_RF
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM OWC
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: OFDM Tx OWC
  states: {}
- name: virtual_source_0_0_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: OFDM Tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Header_OWC
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Header_RF
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Payload_OWC
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Payload_RF
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM OWC
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: '''10.1.1.'' + node_id'
    port: '8080'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '0']
- [analog_const_source_x_0_0, '0', blocks_stream_mux_0, '2']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_repack_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [blocks_selector_0, '0', digital_crc32_bb_0, '0']
- [blocks_selector_0, '1', digital_crc32_bb_0_0, '0']
- [blocks_stream_mux_0, '0', iio_pluto_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_3, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_3_0, '0']
- [blocks_var_to_msg_0, msgout, epy_block_0_0, trigger]
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_crc32_bb_0_0, '0', digital_packet_headergenerator_bb_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', owc_Hermitian_Symmetry_i_o_same_vec_size_cplus_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0_0, '0', fft_vxx_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_complex_to_real_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_packet_headergenerator_bb_0, '0', virtual_sink_1, '0']
- [digital_packet_headergenerator_bb_0_0, '0', virtual_sink_1_0, '0']
- [epy_block_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [owc_Hermitian_Symmetry_i_o_same_vec_size_cplus_0, '0', fft_vxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_selector_0, '0']
- [virtual_source_0_0_1_0_1, '0', epy_block_0, '0']
- [virtual_source_0_0_1_0_1_0, '0', blocks_stream_mux_0, '1']
- [virtual_source_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_1_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [virtual_source_2, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_2_0, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [virtual_source_3, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_3_0, '0', digital_ofdm_carrier_allocator_cvc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
