options:
  parameters:
    author: Arsalan Ahmed
    generate_options: qt_gui
    id: VPPM_Demodulator_Example
    output_language: python
    title: Example of the VPPM Demodulator
  states: {}

blocks:
- name: demodulator_gain
  id: variable
  parameters:
    value: '3'
  states: {}
- name: max_magnitude
  id: variable
  parameters:
    value: '4'
  states: {}
- name: min_magnitude
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samples_per_pulse
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '20'
  states: {}
- name: LSK
  id: blocks_file_source
  parameters:
    file: /home/arsalan/OOT_Modules/gr-owc/examples/TestFile.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/arsalan/OOT_Modules/gr-owc/examples/TestFile_Output.txt
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: owc_VPPM_Demodulator_0
  id: owc_VPPM_Demodulator
  parameters:
    gain: demodulator_gain
    samples_per_pulse: samples_per_pulse
    samples_per_symbol: samples_per_symbol
  states: {}
- name: owc_VPPM_Modulator_one_0
  id: owc_VPPM_Modulator_one
  parameters:
    max_mag: max_magnitude
    min_mag: min_magnitude
    samples_per_pulse: samples_per_pulse
    samples_per_symbol: samples_per_symbol
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Unmodulated Signal
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: VPPM Modulated Signal
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Demodulated Signal
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
  states: {}

connections:
- [LSK, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', owc_VPPM_Demodulator_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_throttle_0, '0']
- [blocks_uchar_to_float_1, '0', owc_VPPM_Modulator_one_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_1, '0']
- [owc_VPPM_Demodulator_0, '0', blocks_float_to_uchar_0, '0']
- [owc_VPPM_Demodulator_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0, '0']
- [owc_VPPM_Modulator_one_0, '0', blocks_multiply_const_vxx_0, '0']
- [owc_VPPM_Modulator_one_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
