options:
  parameters:
    author: MR
    generate_options: qt_gui
    id: OWC_Channel_Grid
    output_language: python
    title: OWC Channel Response with Grid Display
  states: {}

blocks:
- name: grid_max
  id: variable
  parameters:
    value: '10'
  states: {}
- name: grid_min
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: x_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Rx1 - X Position
    orient: Qt.Horizontal
    start: grid_min
    step: '0.5'
    stop: grid_max
    value: '5'
  states: {}
- name: x_tx1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Tx1 - X Position
    orient: Qt.Horizontal
    start: grid_min
    step: '0.5'
    stop: grid_max
    value: '2.5'
  states: {}
- name: x_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Tx2 - X Position
    orient: Qt.Horizontal
    start: grid_min
    step: '0.5'
    stop: grid_max
    value: '7.5'
  states: {}
- name: y_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Rx1 - Y Position
    orient: Qt.Horizontal
    start: grid_min
    step: '0.5'
    stop: grid_max
    value: '5'
  states: {}
- name: y_tx1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    label: Tx1 - Y Position
    orient: Qt.Horizontal
    start: grid_min
    step: '0.5'
    stop: grid_max
    value: '5'
  states: {}
- name: y_tx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Tx2 - Y Position
    orient: Qt.Horizontal
    start: grid_min
    step: '0.5'
    stop: grid_max
    value: '5'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: x_tx1 + y_tx1*1j
    type: complex
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: x_tx2 + y_tx2*1j
    type: complex
  states: {}
- name: analog_const_source_x_0_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: x_rx1 + y_rx1*1j
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/4
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: owc_OWC_Channel_absolute_0
  id: owc_OWC_Channel_absolute
  parameters:
    E2O_conversion_factor_array: '[1.0, 1.0]'
    O2E_conversion_factor_array: '[1.0]'
    concentrator_FOV_array: '[90.0]'
    num_inputs: '2'
    num_outputs: '1'
    optical_filter_transmittance_array: '[1.0]'
    refractive_index_array: '[1.0]'
    rx_coordinates_array: '[x_rx1, y_rx1, 1.0]'
    rx_orientation_array: '[0, 0, 1.0]'
    rx_photosensor_area_array: '[1.0]'
    tx_coordinates_array: '[x_tx1, y_tx1, 2.0, x_tx2, y_tx2, 2.0]'
    tx_lambertian_order_array: '[1.0, 1.0]'
    tx_orientation_array: '[0, 0, -1.0, 0, 0, -1.0]'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color2: '"Dark Blue"'
    color3: '"red"'
    gui_hint: 2,0,1,1
    label1: Tx 1
    label2: Tx 2
    label3: Rx 1
    nconnections: '3'
    size: '1024'
    type: complex
    update_time: '0.01'
    xmax: grid_max
    xmin: grid_min
    ymax: grid_max
    ymin: grid_min
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,2
    plotconst: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_0_0_0_0, '0', qtgui_const_sink_x_0, '1']
- [analog_const_source_x_0_0_0_0_0, '0', qtgui_const_sink_x_0, '2']
- [analog_sig_source_x_0, '0', owc_OWC_Channel_absolute_0, '0']
- [analog_sig_source_x_0_0, '0', owc_OWC_Channel_absolute_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_sink_x_0, '0']
- [owc_OWC_Channel_absolute_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
