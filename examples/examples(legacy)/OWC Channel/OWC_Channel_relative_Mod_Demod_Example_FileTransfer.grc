options:
  parameters:
    author: Arsalan Ahmed
    generate_options: qt_gui
    id: OWC_Channel_relative_Mod_Demod_Example_FileTransfer
    output_language: python
    title: Example of the relative channel model with Modulators and Demodulators
  states: {}

blocks:
- name: Max
  id: variable_function_probe
  parameters:
    block_id: maximum
    function_name: level
    poll_rate: '10'
    value: '0.001'
  states: {}
- name: Maximum_value
  id: variable_qtgui_label
  parameters:
    type: real
    value: Max
  states: {}
- name: Min
  id: variable_function_probe
  parameters:
    block_id: minimum
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: Minimum_value
  id: variable_qtgui_label
  parameters:
    type: real
    value: Min
  states: {}
- name: average_val
  id: variable_qtgui_label
  parameters:
    type: real
    value: threshold
  states: {}
- name: averaging_window_size
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: d_1_1
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: d_1_2
  id: variable
  parameters:
    value: '100'
  states: {}
- name: d_1_3
  id: variable
  parameters:
    value: '100'
  states: {}
- name: d_2_1
  id: variable
  parameters:
    value: '100'
  states: {}
- name: d_2_2
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: d_2_3
  id: variable
  parameters:
    value: '100'
  states: {}
- name: d_3_1
  id: variable
  parameters:
    value: '100'
  states: {}
- name: d_3_2
  id: variable
  parameters:
    value: '100'
  states: {}
- name: d_3_3
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: max_magnitude_tx1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: max_magnitude_tx2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: max_magnitude_tx3
  id: variable
  parameters:
    value: '4'
  states: {}
- name: min_magnitude_tx1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: min_magnitude_tx2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: min_magnitude_tx3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: modulation_order_tx2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rx_A
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: samples_per_pulse_tx3
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samples_per_symbol_tx1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samples_per_symbol_tx2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samples_per_symbol_tx3
  id: variable
  parameters:
    value: '5'
  states: {}
- name: threshold
  id: variable_function_probe
  parameters:
    block_id: average
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: tx_m
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_phi_1_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_phi_1_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_phi_1_3
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_phi_2_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_phi_2_2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_phi_2_3
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_phi_3_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_phi_3_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_phi_3_3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_psi_1_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_psi_1_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_psi_1_3
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_psi_2_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_psi_2_2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_psi_2_3
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_psi_3_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_psi_3_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: tx_psi_3_3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: LSK
  id: blocks_file_source
  parameters:
    file: File_A
    repeat: 'True'
    type: byte
  states: {}
- name: LSK_0
  id: blocks_file_source
  parameters:
    file: File_B
    repeat: 'True'
    type: byte
  states: {}
- name: LSK_0_0
  id: blocks_file_source
  parameters:
    file: File_C
    repeat: 'True'
    type: byte
  states: {}
- name: average
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: OOK_output.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: PAM_output.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: VPPM_output.txt
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: window_size
    vlen_out: '1'
  states: {}
- name: blocks_min_xx_0
  id: blocks_min_xx
  parameters:
    type: float
    vlen: window_size
    vlen_out: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: averaging_window_size
    max_iter: '4000'
    scale: 1/averaging_window_size
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: window_size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: window_size
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: maximum
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: minimum
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: owc_OOK_Demodulator_0
  id: owc_OOK_Demodulator
  parameters:
    samples_per_symbol: samples_per_symbol_tx1
    threshold: threshold
  states: {}
- name: owc_OOK_Modulator_one_0
  id: owc_OOK_Modulator_one
  parameters:
    max_mag: max_magnitude_tx1
    min_mag: min_magnitude_tx1
    samples_per_symbol: samples_per_symbol_tx1
  states: {}
- name: owc_OWC_Channel_relative_0
  id: owc_OWC_Channel_relative
  parameters:
    E2O_conversion_factor_array: '[1.0, 1.0, 1.0]'
    O2E_conversion_factor_array: '[1.0, 1.0, 1.0]'
    acceptance_angle_array: '[tx_psi_1_1, tx_psi_1_2, tx_psi_1_3, tx_psi_2_1, tx_psi_2_2, tx_psi_2_3, tx_psi_3_1, tx_psi_3_2, tx_psi_3_3]'
    concentrator_FOV_array: '[90, 90, 90]'
    distance_array: '[d_1_1, d_1_2, d_1_3, d_2_1, d_2_2, d_2_3,d_3_1, d_3_2, d_3_3]'
    emission_angle_array: '[tx_phi_1_1, tx_phi_1_2, tx_phi_1_3,  tx_phi_2_1, tx_phi_2_2, tx_phi_2_3,  tx_phi_3_1, tx_phi_3_2, tx_phi_3_3]'
    lambertian_order_array: '[tx_m, tx_m, tx_m]'
    num_inputs: '3'
    num_outputs: '3'
    optical_filter_transmittance_array: '[1.0, 1.0, 1.0]'
    photosensor_area_array: '[rx_A, rx_A,  rx_A]'
    refractive_index_array: '[1.0, 1.0, 1.0]'
  states: {}
- name: owc_PAM_Demodulator_0
  id: owc_PAM_Demodulator
  parameters:
    max_mag: Max
    min_mag: Min
    mod_order: modulation_order_tx2
    samples_per_symbol: samples_per_symbol_tx2
  states: {}
- name: owc_PAM_Modulator_one_0
  id: owc_PAM_Modulator_one
  parameters:
    max_mag: max_magnitude_tx2
    min_mag: min_magnitude_tx2
    mod_order: modulation_order_tx2
    samples_per_symbol: samples_per_symbol_tx2
  states: {}
- name: owc_VPPM_Demodulator_0
  id: owc_VPPM_Demodulator
  parameters:
    gain: '1'
    samples_per_pulse: samples_per_pulse_tx3
    samples_per_symbol: samples_per_symbol_tx3
  states: {}
- name: owc_VPPM_Modulator_one_0
  id: owc_VPPM_Modulator_one
  parameters:
    max_mag: max_magnitude_tx3
    min_mag: min_magnitude_tx3
    samples_per_pulse: samples_per_pulse_tx3
    samples_per_symbol: samples_per_symbol_tx3
  states: {}
- name: owc_binary_to_decimal_mapper_0
  id: owc_binary_to_decimal_mapper
  parameters:
    mod_order: modulation_order_tx2
  states: {}
- name: owc_decimal_to_binary_mapper_0
  id: owc_decimal_to_binary_mapper
  parameters:
    mod_order: modulation_order_tx2
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Rx2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Rx3
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Rx1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Rx2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Rx3
  states: {}

connections:
- [LSK, '0', blocks_unpack_k_bits_bb_0, '0']
- [LSK_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [LSK_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_float_to_uchar_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_max_xx_0, '0', maximum, '0']
- [blocks_min_xx_0, '0', minimum, '0']
- [blocks_moving_average_xx_0, '0', average, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_file_sink_0_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_min_xx_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_1_0, '0', owc_OOK_Modulator_one_0, '0']
- [blocks_uchar_to_float_1_0_0, '0', owc_binary_to_decimal_mapper_0, '0']
- [blocks_uchar_to_float_1_0_0_0, '0', owc_VPPM_Modulator_one_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_uchar_to_float_1_0_0_0, '0']
- [owc_OOK_Demodulator_0, '0', blocks_float_to_uchar_0_0, '0']
- [owc_OOK_Modulator_one_0, '0', owc_OWC_Channel_relative_0, '0']
- [owc_OWC_Channel_relative_0, '0', virtual_sink_0, '0']
- [owc_OWC_Channel_relative_0, '1', virtual_sink_0_0, '0']
- [owc_OWC_Channel_relative_0, '2', virtual_sink_0_0_0, '0']
- [owc_PAM_Demodulator_0, '0', owc_decimal_to_binary_mapper_0, '0']
- [owc_PAM_Modulator_one_0, '0', owc_OWC_Channel_relative_0, '1']
- [owc_VPPM_Demodulator_0, '0', blocks_float_to_uchar_0_0_0, '0']
- [owc_VPPM_Modulator_one_0, '0', owc_OWC_Channel_relative_0, '2']
- [owc_binary_to_decimal_mapper_0, '0', owc_PAM_Modulator_one_0, '0']
- [owc_decimal_to_binary_mapper_0, '0', blocks_float_to_uchar_0, '0']
- [virtual_source_0_0, '0', blocks_moving_average_xx_0, '0']
- [virtual_source_0_0, '0', owc_OOK_Demodulator_0, '0']
- [virtual_source_0_0_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0_0_0, '0', owc_PAM_Demodulator_0, '0']
- [virtual_source_0_1, '0', owc_VPPM_Demodulator_0, '0']

metadata:
  file_format: 1
