options:
  parameters:
    author: 'MR '
    category: Custom
    description: (modified from Arsalan's DCO-OFDM Flowgraph in gr-owc)
    generate_options: qt_gui
    id: dco_ofdm_rx_parameter2
    output_language: python
    run_options: run
    title: DCO-OFDM Rx Parameter 2
  states: {}

blocks:
- name: OC_3
  id: variable
  parameters:
    value: (list(range(-24, -18)) + list(range(-12, -8)),)
  states: {}
- name: OC_high
  id: variable
  parameters:
    value: (list(range(-22, -12)),)
  states: {}
- name: OC_low
  id: variable
  parameters:
    value: (list(range(-12, -2)),)
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fn_full
  id: variable
  parameters:
    value: f_dir + fn + '.txt'
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {state: disabled}
- name: my_select_2
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Subcarrier Select
    label0: Low
    label1: High
    label2: Mix
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '2'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: OC_low
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '46'
  states: {state: disabled}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-28,-1),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((-1,1),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: samp_rate_usrp
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fn_full
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: my_select_2
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: my_select_2
    type: complex
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: OC_low
    packet_len_key: '"length"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: OC_high
    packet_len_key: '"length"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_rx_0_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: OC_3
    packet_len_key: '"length"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: f_dir
  id: parameter
  parameters:
    label: File Directory
    type: str
    value: '"/home/mrahaim/Desktop/Param_Results/"'
  states: {}
- name: fn
  id: parameter
  parameters:
    type: str
    value: '"results01"'
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Rx Path
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate_usrp
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_usrp
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    plotconst: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,1,2
    legend: 'False'
    name: Received Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_usrp
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_usrp
    sync: none
    type: fc32
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 10.1.1.3
    port: '8080'
  states: {state: disabled}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '0', blocks_tag_gate_1, '0']
- [blocks_selector_0_0, '0', digital_ofdm_rx_0, '0']
- [blocks_selector_0_0, '1', digital_ofdm_rx_0_0, '0']
- [blocks_selector_0_0, '2', digital_ofdm_rx_0_0_0, '0']
- [blocks_tag_gate_1, '0', blocks_file_sink_0, '0']
- [blocks_tag_gate_1, '0', blocks_uchar_to_float_0, '0']
- [blocks_tag_gate_1, '0', vocoder_cvsd_decode_bf_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2_0, '0']
- [digital_ofdm_rx_0, '0', blocks_selector_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_selector_0, '1']
- [digital_ofdm_rx_0_0_0, '0', blocks_selector_0, '2']
- [uhd_usrp_source_0, '0', blocks_selector_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
