options:
  parameters:
    author: UCan_Lab
    description: Transmits Packets over RF with B200Mini
    generate_options: qt_gui
    id: RF_Packet_Error_Rate
    output_language: python
    title: RF_Packet_Error_Testing
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: packet_len
  states: {}
- name: oc_high
  id: variable
  parameters:
    value: (-4,-3,3,4)
  states: {}
- name: oc_low
  id: variable
  parameters:
    value: (-3,3)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: path_select
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: oc_high
    option1: oc_low
    type: raw
    value: oc_high
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: RX Packets
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: range(0,20)
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: path_select
    packet_len_key: packet_len
    payload_mod: '"QPSK"'
    pilot_carriers: (-6,-5,5,6)
    pilot_symbols: (-1,1,-1,1)
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: path_select
    packet_len_key: packet_len
    payload_mod: '"QPSK"'
    pilot_carriers: (-6,-5,5,6)
    pilot_symbols: (-1,1,-1,1)
    rolloff: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX Specturm
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: RX Address
    short_id: r
    type: str
    value: '3279500'
  states: {}
- name: tx_addr
  id: parameter
  parameters:
    label: TX Address
    short_id: t
    type: str
    value: '3279417'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '915000000'
    dev_addr: '"serial=" + tx_addr'
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    dev_addr: '"serial=" + tx_addr'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_tx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
