options:
  parameters:
    author: ucanlab
    category: Custom
    description: (modified from Arsalan's DCO-OFDM Flowgraph in gr-owc)
    generate_options: qt_gui
    id: dco_ofdm_tx_select_2
    output_language: python
    run_options: run
    title: Two channel DCO-OFDM Tx with Subcarrier - Select
  states: {}

blocks:
- name: OC_3
  id: variable
  parameters:
    value: (list(range(-24, -18)) + list(range(-12, -8)),)
  states: {}
- name: OC_high
  id: variable
  parameters:
    value: (list(range(-22, -12)),)
  states: {}
- name: OC_int
  id: variable
  parameters:
    value: (list(range(-12, -2)),)
  states: {}
- name: OC_low
  id: variable
  parameters:
    value: (list(range(-12, -2)),)
  states: {}
- name: ch2_enable
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,1
    label: Subcarrier Select
    label0: Disabled
    label1: Enabled
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: path_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,1
    label: Subcarrier Select
    label0: Low
    label1: High
    label2: Mix
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-28,-1),)
  states: {}
- name: pilot_carriers_2
  id: variable
  parameters:
    value: ((-28,-1),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((-1,1),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: samp_rate_usrp
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: DCO_OFDM_Sync_Packetized_Signal_Generator_0
  id: DCO_OFDM_Sync_Packetized_Signal_Generator
  parameters:
    fft_len: fft_len
    occupied_carriers: OC_low
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: DCO_OFDM_Sync_Packetized_Signal_Generator_0_0
  id: DCO_OFDM_Sync_Packetized_Signal_Generator
  parameters:
    fft_len: fft_len
    occupied_carriers: OC_high
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: DCO_OFDM_Sync_Packetized_Signal_Generator_0_0_0
  id: DCO_OFDM_Sync_Packetized_Signal_Generator
  parameters:
    fft_len: fft_len
    occupied_carriers: OC_3
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: DCO_OFDM_Sync_Packetized_Signal_Generator_0_1
  id: DCO_OFDM_Sync_Packetized_Signal_Generator
  parameters:
    fft_len: fft_len
    occupied_carriers: OC_int
    pilot_carriers: pilot_carriers_2
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mrahaim/Desktop/Data_File
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0125'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0125'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ch2_enable
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mrahaim/Desktop/StarWars60.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mrahaim/Desktop/imperial_march.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Tx Data Path
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Tx Signal Path
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Add WAV File!!
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_usrp
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,4
    name: '"Channel 1"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_usrp
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,4
    name: '"Channel 2"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: AB
    center_freq0: '0'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_usrp
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Tx Data
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Tx Data
  states: {state: disabled}
- name: virtual_sink_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Tx Data
  states: {state: disabled}
- name: virtual_source_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Tx Data
  states: {}
- name: vocoder_cvsd_encode_fb_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}
- name: vocoder_cvsd_encode_fb_0_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 10.1.1.2
    port: '8080'
  states: {}

connections:
- [DCO_OFDM_Sync_Packetized_Signal_Generator_0, '0', blocks_selector_0, '0']
- [DCO_OFDM_Sync_Packetized_Signal_Generator_0_0, '0', blocks_selector_0, '1']
- [DCO_OFDM_Sync_Packetized_Signal_Generator_0_0_0, '0', blocks_selector_0, '2']
- [DCO_OFDM_Sync_Packetized_Signal_Generator_0_1, '0', blocks_selector_0_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0_0_0_1_0, '0']
- [blocks_float_to_complex_2, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_2, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_float_to_complex_2, '1']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_real_0, '0']
- [blocks_selector_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0_0_0_0_1, '0']
- [blocks_wavfile_source_0, '0', vocoder_cvsd_encode_fb_0, '0']
- [blocks_wavfile_source_0_0, '0', vocoder_cvsd_encode_fb_0_0, '0']
- [virtual_source_0_0_1_0_0, '0', DCO_OFDM_Sync_Packetized_Signal_Generator_0, '0']
- [virtual_source_0_0_1_0_0, '0', DCO_OFDM_Sync_Packetized_Signal_Generator_0_0, '0']
- [virtual_source_0_0_1_0_0, '0', DCO_OFDM_Sync_Packetized_Signal_Generator_0_0_0, '0']
- [vocoder_cvsd_encode_fb_0, '0', virtual_sink_0_0_0_0, '0']
- [vocoder_cvsd_encode_fb_0_0, '0', DCO_OFDM_Sync_Packetized_Signal_Generator_0_1, '0']

metadata:
  file_format: 1
