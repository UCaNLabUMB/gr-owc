options:
  parameters:
    author: Arsalan Ahmed
    generate_options: qt_gui
    id: OWC_Channel_relative_Example
    output_language: python
    title: Example of the relative channel model
  states: {}

blocks:
- name: d_1_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: d_1_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: d_2_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: d_2_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 16,0
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: m_1_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_A_1
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: rx_A_2
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: rx_C_r_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_C_r_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_psi_1_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rx_psi_1_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: rx_psi_2_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: rx_psi_2_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 15,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rx_psi_c_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: rx_psi_c_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: tx_C_t_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_C_t_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_m_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 19,0
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: tx_m_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 20,0
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: tx_phi_1_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: tx_phi_1_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: tx_phi_2_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: tx_phi_2_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.0000001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1000*10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: owc_OWC_Channel_relative_0
  id: owc_OWC_Channel_relative
  parameters:
    E2O_conversion_factor_array: '[tx_C_t_1, tx_C_t_2]'
    O2E_conversion_factor_array: '[rx_C_r_1, rx_C_r_2]'
    acceptance_angle_array: '[rx_psi_1_1, rx_psi_1_2, rx_psi_2_1, rx_psi_2_2]'
    concentrator_FOV_array: '[rx_psi_c_1, rx_psi_c_2]'
    distance_array: '[d_1_1, d_1_2, d_2_1, d_2_2]'
    emission_angle_array: '[tx_phi_1_1, tx_phi_1_2, tx_phi_2_1, tx_phi_2_2]'
    lambertian_order_array: '[tx_m_1, tx_m_2]'
    num_inputs: '2'
    num_outputs: '2'
    optical_filter_transmittance_array: '[rx_Ts_1, rx_Ts_2]'
    photosensor_area_array: '[rx_A_1, rx_A_2]'
    refractive_index_array: '[rx_n_1, rx_n_2]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color2: '"yellow"'
    fc: '0'
    fftsize: '1024'
    gui_hint: 10,0
    label1: Rx 1 Frequency Domain
    label2: Rx 2 Frequency Domain
    name: Rx's Frequency Domain
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    gui_hint: 9,0
    name: '"Rx 1 Time Domain"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: magenta
    gui_hint: 17,0
    name: '"Rx 2 Time Domain"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    entags: 'False'
    gui_hint: 0,0
    name: '"Tx 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: 1,0
    name: '"Tx 2"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-110'
    int_min: '-190'
    name: Rx 2 Waterfall
    type: float
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', owc_OWC_Channel_relative_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', owc_OWC_Channel_relative_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_add_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_0, '0']
- [owc_OWC_Channel_relative_0, '0', blocks_add_xx_0, '0']
- [owc_OWC_Channel_relative_0, '1', blocks_add_xx_0_0, '0']

metadata:
  file_format: 1
