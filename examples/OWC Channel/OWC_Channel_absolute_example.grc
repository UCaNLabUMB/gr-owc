options:
  parameters:
    author: Arsalan Ahmed
    generate_options: qt_gui
    id: OWC_Channel_absolute_Example
    output_language: python
    title: Example of the absolute channel model
  states: {}

blocks:
- name: rx_A_1
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: rx_A_2
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: rx_C_r_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_C_r_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_psi_c_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: rx_psi_c_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: rx_u_x_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_x_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_y_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_y_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,1,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_z_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,2,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '-1'
  states: {}
- name: rx_u_z_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,2,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '-1'
  states: {}
- name: rx_x_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rx_x_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: rx_y_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rx_y_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rx_z_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: rx_z_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,2,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: tx_C_t_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_C_t_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_m_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: tx_m_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: tx_u_x_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_x_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_y_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_y_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_z_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: tx_u_z_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: tx_x_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_x_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: tx_y_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_y_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_z_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_z_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: tx_y_1
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: tx_x_1
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: tx_x_2
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: rx_x_2
    type: float
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: rx_x_1
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: tx_y_2
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: rx_y_2
    type: float
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: rx_y_1
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: owc_OWC_Channel_absolute_0
  id: owc_OWC_Channel_absolute
  parameters:
    E2O_conversion_factor_array: '[tx_C_t_1, tx_C_t_2]'
    O2E_conversion_factor_array: '[rx_C_r_1, rx_C_r_2]'
    concentrator_FOV_array: '[rx_psi_c_1, rx_psi_c_2]'
    num_inputs: '2'
    num_outputs: '2'
    optical_filter_transmittance_array: '[rx_Ts_1, rx_Ts_2]'
    refractive_index_array: '[rx_n_1, rx_n_2]'
    rx_coordinates_array: '[rx_x_1, rx_y_1, rx_z_1 , rx_x_2, rx_y_2, rx_z_2]'
    rx_orientation_array: '[rx_u_x_1, rx_u_y_1, rx_u_z_1 , rx_u_x_2, rx_u_y_2, rx_u_z_2]'
    rx_photosensor_area_array: '[rx_A_1, rx_A_2]'
    tx_coordinates_array: '[tx_x_1, tx_y_1, tx_z_1 , tx_x_2, tx_y_2, tx_z_2]'
    tx_lambertian_order_array: '[tx_m_1, tx_m_2]'
    tx_orientation_array: '[tx_u_x_1, tx_u_y_1, tx_u_z_1 , tx_u_x_2, tx_u_y_2, tx_u_z_2]'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color4: '"yellow"'
    gui_hint: 11,0,1,3
    label1: Tx 1
    label2: Tx 2
    label3: Rx 1
    label4: Rx 2
    name: '"Tx Rx X&Y location coordinates"'
    nconnections: '4'
    size: '1024'
    type: complex
    xmax: '10'
    xmin: '-10'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 13,0,1,3
    legend: 'False'
    name: '"Rx 1 Frequency Domain"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"yellow"'
    fc: '0'
    fftsize: '1024'
    gui_hint: 15,0,1,3
    legend: 'False'
    name: '"Rx 2 Frequency Domain"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 12,0,1,3
    legend: 'False'
    name: '"Rx 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 14,0,1,3
    legend: 'False'
    name: '"Rx 2"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    gui_hint: 0,0,1,3
    legend: 'False'
    name: '"Tx 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    entags: 'False'
    gui_hint: 1,0,1,3
    legend: 'False'
    name: '"Tx 2"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_const_source_x_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0, '0']
- [analog_const_source_x_0_0_1, '0', blocks_float_to_complex_0_0_0, '0']
- [analog_const_source_x_0_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_1_0, '0', blocks_float_to_complex_0_0_0_0, '1']
- [analog_const_source_x_0_2, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', owc_OWC_Channel_absolute_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_float_to_complex_0_0_0, '0', qtgui_const_sink_x_0, '2']
- [blocks_float_to_complex_0_0_0_0, '0', qtgui_const_sink_x_0, '3']
- [blocks_throttle_0, '0', owc_OWC_Channel_absolute_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [owc_OWC_Channel_absolute_0, '0', qtgui_freq_sink_x_0, '0']
- [owc_OWC_Channel_absolute_0, '0', qtgui_time_sink_x_0, '0']
- [owc_OWC_Channel_absolute_0, '1', qtgui_freq_sink_x_0_0, '0']
- [owc_OWC_Channel_absolute_0, '1', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
