options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: tx_dco_ofdm
    output_language: python
    run_options: run
    title: DCO_OFDM Tx
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, -1),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (10, 20, 30, 40)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"length"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: owc_DCO_OFDM_Hermitian_Symmetry_0
  id: owc_DCO_OFDM_Hermitian_Symmetry
  parameters:
    fft_len: '64'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: FFT Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0
    label1: Scope Plot
    label2: ''
    name: Scope Plot
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0
    name: Received Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: OFDM Signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: OFDM Signal
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', header_bits, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_tag_gate_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_tag_gate_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', owc_DCO_OFDM_Hermitian_Symmetry_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [owc_DCO_OFDM_Hermitian_Symmetry_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_0_0_0_0, '0', digital_ofdm_rx_0, '0']

metadata:
  file_format: 1
