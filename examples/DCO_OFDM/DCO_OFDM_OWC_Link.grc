options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: DCO_OFDM
    output_language: python
    title: DCO OFDM Example
  states: {}

blocks:
- name: d_1_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rx_A_1
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: rx_C_r_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_psi_c_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: tx_phi_1_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_psi_1_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Complex_down_conversion_0
  id: Complex_down_conversion
  parameters: {}
  states: {}
- name: LED_frequency_response_0
  id: LED_frequency_response
  parameters: {}
  states: {}
- name: LSK
  id: blocks_file_source
  parameters:
    file: /home/arsalan/OOT_Modules/gr-owc/examples/TestFile.txt
    repeat: 'True'
    type: byte
  states: {}
- name: Up_conversion_0
  id: Up_conversion
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/arsalan/OOT_Modules/gr-owc/examples/output.txt
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/20
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.00001'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((4,3,2,1,-1,-2,-3,-4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((4,3,2,1,-1,-2,-3,-4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: owc_OWC_Channel_relative_0
  id: owc_OWC_Channel_relative
  parameters:
    E2O_conversion_factor_array: '[1.0]'
    O2E_conversion_factor_array: '[1.0]'
    acceptance_angle_array: '[tx_psi_1_1]'
    concentrator_FOV_array: '[90]'
    distance_array: '[d_1_1]'
    emission_angle_array: '[tx_phi_1_1]'
    lambertian_order_array: '[0.5]'
    num_inputs: '1'
    num_outputs: '1'
    optical_filter_transmittance_array: '[1.0]'
    photosensor_area_array: '[rx_A_1]'
    refractive_index_array: '[1.0]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0
    label1: Rx Spectrum
    name: Received OFDM Signal
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    label1: Tx Spectrum
    name: Transmitted OFDM Signal
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0
    label1: Channel Spectrum
    name: Signal in the OWC Channel
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,0
    label1: ''
    name: Received Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0
    label1: ''
    name: Transmitted Data
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Complex_down_conversion_0, '0', channels_channel_model_0, '0']
- [LED_frequency_response_0, '0', Complex_down_conversion_0, '0']
- [LED_frequency_response_0, '0', qtgui_freq_sink_x_0_1, '0']
- [LSK, '0', blocks_stream_to_tagged_stream_0, '0']
- [LSK, '0', blocks_uchar_to_float_1, '0']
- [Up_conversion_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', owc_OWC_Channel_relative_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_tag_gate_0, '0', blocks_file_sink_0, '0']
- [blocks_tag_gate_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_0, '0', digital_ofdm_rx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_gate_0, '0']
- [digital_ofdm_tx_0, '0', Up_conversion_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [owc_OWC_Channel_relative_0, '0', LED_frequency_response_0, '0']

metadata:
  file_format: 1
