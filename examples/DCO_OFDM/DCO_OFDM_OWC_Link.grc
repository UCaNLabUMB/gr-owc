options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: DCO_OFDM
    output_language: python
    title: DCO OFDM Example
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: Complex_down_conversion_0
  id: Complex_down_conversion
  parameters: {}
  states: {}
- name: LSK
  id: blocks_file_source
  parameters:
    file: File_A
    repeat: 'True'
    type: byte
  states: {}
- name: OWC_Channel_Full_0
  id: OWC_Channel_Full
  parameters: {}
  states: {}
- name: Up_conversion_0
  id: Up_conversion
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: DCO_OFDM_output.txt
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((4,3,2,1,-1,-2,-3,-4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((4,3,2,1,-1,-2,-3,-4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}

connections:
- [Complex_down_conversion_0, '0', digital_ofdm_rx_0, '0']
- [LSK, '0', blocks_stream_to_tagged_stream_0, '0']
- [OWC_Channel_Full_0, '0', Complex_down_conversion_0, '0']
- [Up_conversion_0, '0', OWC_Channel_Full_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_tag_gate_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_gate_0, '0']
- [digital_ofdm_tx_0, '0', Up_conversion_0, '0']

metadata:
  file_format: 1
