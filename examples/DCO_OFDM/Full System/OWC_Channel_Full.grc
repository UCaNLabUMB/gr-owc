options:
  parameters:
    author: arsalan
    generate_options: hb
    id: OWC_Channel_Full
    output_language: python
    title: OWC Channel Full
  states: {}

blocks:
- name: d_1_1
  id: variable
  parameters:
    value: '100e-3'
  states: {}
- name: rx_A_1
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: rx_C_r_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_psi_c_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: tx_phi_1_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_psi_1_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LED_frequency_response_0
  id: LED_frequency_response
  parameters: {}
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.00001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: owc_OWC_Channel_relative_0
  id: owc_OWC_Channel_relative
  parameters:
    E2O_conversion_factor_array: '[1.0]'
    O2E_conversion_factor_array: '[1.0]'
    acceptance_angle_array: '[tx_psi_1_1]'
    concentrator_FOV_array: '[90]'
    distance_array: '[d_1_1]'
    emission_angle_array: '[tx_phi_1_1]'
    lambertian_order_array: '[0.5]'
    num_inputs: '1'
    num_outputs: '1'
    optical_filter_transmittance_array: '[1.0]'
    photosensor_area_array: '[rx_A_1]'
    refractive_index_array: '[1.0]'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [LED_frequency_response_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [owc_OWC_Channel_relative_0, '0', LED_frequency_response_0, '0']
- [pad_source_0, '0', owc_OWC_Channel_relative_0, '0']

metadata:
  file_format: 1
