options:
  parameters:
    author: arsalan
    generate_options: hb
    id: Complex_down_conversion
    output_language: python
    title: Complex_down_conversion_with_LPF
  states: {}

blocks:
- name: mod_freq
  id: variable
  parameters:
    value: (400e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: mod_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: mod_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 120e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_float_to_complex_0_0_1, '0']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_float_to_complex_0_0_1, '1']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_complex_0_0_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_complex_0_0, '0']

metadata:
  file_format: 1
