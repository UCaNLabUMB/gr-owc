options:
  parameters:
    author: Vahae Ohanian (VahaeO@mail.fresnostate.edu), Jordan DiViccaro (Jordan1@mail.fresnostate.edu), HaoYuan "James" Wu (Jameswu91@mail.fresnostate.edu), Gregory Dzhezyan (Gregorydz@mail.fresnostate.edu), California State University-Fresno
    generate_options: qt_gui
    id: OFDM_Point_to_Point_and_Synchronization_Audio
    output_language: python
    title: OFDM_Point_to_Point&Synchronization_Audio
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(64, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key_1, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: length_tag_key_0
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: length_tag_key_1
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(64, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: size
  id: variable
  parameters:
    value: '128'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[1+1j,-1+1j,1-1j,-1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '120'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/fresnostate/Desktop/textofdm
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '44100'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (10 ,71 ,52 ,132 ,27 ,48 ,115 ,88 ,104 ,57 ,10 ,47 ,133 ,138 ,17 ,81 ,78 ,161 ,18 ,160 ,91 ,151 ,7 ,243 ,110 ,244 ,152 ,169 ,26 ,78 ,108 ,248 ,30 ,234 ,138 ,36 ,253 ,103 ,102 ,254 ,111 ,110 ,36 ,92 ,57 ,185 ,253 ,31 ,151 ,52 ,136 ,222 ,117 ,198 ,235 ,25 ,58 ,20 ,85 ,127 ,20 ,28 ,122 ,129 ,72 ,180 ,161 ,100 ,28 ,85 ,110 ,177 ,60 ,158 ,173 ,153 ,23 ,105 ,171 ,40 ,192 ,49 ,4 ,220 ,140 ,25 ,55 ,100 ,121 ,253 ,252 ,163 ,211 ,112 ,177 ,178 ,107 ,209 ,64 ,176 ,115 ,22 ,40 ,240 ,38 ,0 ,170 ,25 ,250 ,139 ,85 ,127 ,244 ,203 ,223 ,253 ,160 ,222 ,62 ,28 ,105 ,141 ,174 ,47 ,164 ,183 ,74 ,51 ,106 ,197 ,155 ,106 ,204 ,222 ,83 ,164 ,160 ,79 ,102 ,26 ,247 ,170 ,237 ,221 ,159 ,239 ,38 ,186 ,113 ,154 ,82 ,62 ,162 ,205 ,54 ,243 ,73 ,93 ,90 ,4 ,252 ,189 ,4 ,153 ,104 ,180 ,50 ,250 ,79 ,35 ,64 ,1 ,251 ,141 ,111 ,193 ,149 ,165 ,165 ,192 ,224 ,114 ,156 ,2 ,107 ,120 ,195 ,219 ,67 ,48 ,228 ,174 ,107 ,49 ,148 ,43 ,252 ,199 ,0 ,251 ,38 ,238 ,192 ,38 ,72 ,90 ,20 ,150 ,197 ,125 ,86 ,75 ,215 ,233 ,250 ,97 ,170 ,249 ,53 ,158 ,68 ,36 ,128 ,231 ,32 ,17 ,182 ,141 ,105 ,70 ,141 ,193 ,67 ,19 ,116 ,137 ,75 ,193 ,113 ,230 ,240 ,11 ,120 ,42 ,119 ,72 ,186 ,62 ,90 ,205 ,90 ,175 ,204 ,239 ,35 ,245 ,112 ,183 ,160 ,5 ,186 ,3 ,107 ,229 ,153 ,43 ,10 ,220 ,96 ,168 ,96 ,4 ,118 ,37 ,113 ,132 ,224 ,226 ,154 ,13 ,93 ,137 ,85 ,134 ,178 ,138 ,228 ,224 ,186 ,70 ,214 ,202 ,96 ,223 ,190 ,77 ,160 ,230 ,239 ,100 ,252 ,61 ,24 ,8 ,175 ,173 ,92 ,114 ,54 ,178 ,142 ,84 ,210 ,232 ,92 ,135 ,254 ,189 ,238 ,150 ,102 ,196 ,34 ,220 ,126 ,72 ,205 ,149 ,253 ,49 ,93 ,77 ,128 ,182 ,161 ,33 ,2 ,170 ,9 ,223 ,9 ,53 ,71 ,125 ,94 ,156 ,9 ,19 ,13 ,157 ,228 ,156 ,166 ,99 ,58 ,13 ,109 ,73 ,129 ,212 ,210 ,186 ,23 ,32 ,96 ,146 ,110 ,41 ,152 ,61 ,14 ,87 ,204 ,164 ,6 ,89 ,44 ,254 ,131 ,196 ,215 ,240 ,208 ,212 ,157 ,122 ,69 ,110 ,64 ,48 ,96 ,56 ,102 ,206 ,100 ,193 ,10 ,191 ,108 ,37 ,46 ,44 ,119 ,129 ,172 ,184 ,165 ,221 ,11 ,195 ,116 ,143 ,141 ,150 ,61 ,206 ,117 ,174 ,231 ,220 ,207 ,134 ,225 ,40 ,130 ,165 ,149 ,67 ,210 ,213 ,2 ,87 ,1 ,38 ,254 ,23 ,241 ,104 ,177 ,83 ,216 ,183 ,147 ,57 ,249 ,199 ,119 ,200 ,12 ,225 ,148 ,211 ,1 ,173 ,126 ,182 ,102 ,32 ,212 ,46 ,88 ,54 ,253 ,186 ,128 ,6 ,214 ,123 ,254 ,190 ,41 ,160 ,233 ,251 ,59 ,248 ,139 ,60 ,163 ,164 ,61 ,210 ,158 ,66 ,161 ,163 ,64 ,84 ,113 ,111 ,148 ,110 ,156 ,209 ,69 ,151 ,39 ,226 ,123 ,228 ,228 ,94 ,242 ,97 ,44 ,193 ,169 ,236 ,65 ,21 ,203 ,48 ,132 ,13 ,71 ,37 ,115 ,162 ,19 ,240 ,130 ,180 ,118 ,145 ,25 ,196 ,231 ,178 ,95 ,121 ,251 ,90 ,108 ,241 ,112 ,123 ,66 ,64 ,243 ,85 ,28 ,98 ,157 ,169 ,64 ,243 ,55 ,182 ,169 ,128 ,166 ,126 ,1 ,34 ,206 ,129 ,144 ,66 ,60 ,105 ,70 ,140 ,121 ,36 ,8 ,105 ,184 ,41 ,102 ,155 ,178 ,104 ,19 ,176 ,77 ,220 ,115 ,233 ,115 ,216 ,151 ,117 ,175 ,185 ,85 ,33 ,59 ,23 ,87 ,132 ,250 ,99 ,164 ,84 ,240 ,32 ,172 ,235 ,189 ,43 ,117 ,107 ,28 ,78 ,239 ,73 ,147 ,2 ,166 ,86 ,181 ,204 ,202 ,239 ,206 ,32 ,203 ,252 ,126 ,137 ,211 ,54 ,75 ,239 ,222 ,238 ,178 ,198 ,152 ,213 ,252 ,25 ,166 ,228 ,24 ,204 ,92 ,139 ,210 ,151 ,59 ,18 ,67 ,111 ,192 ,38 ,242 ,133 ,97 ,166 ,51 ,156 ,4 ,238 ,124 ,16 ,66 ,142 ,4 ,223 ,236 ,237 ,164 ,97 ,249 ,170 ,2 ,132 ,122 ,102 ,231 ,132 ,61 ,77 ,32 ,192 ,241 ,62 ,225 ,79 ,77 ,172 ,242 ,142 ,254 ,163 ,134 ,129 ,1 ,177 ,139 ,191 ,71 ,40 ,47 ,112 ,105 ,6 ,58 ,119 ,60 ,111 ,200 ,125 ,223 ,58 ,59 ,0 ,182 ,5 ,184 ,207 ,176 ,246 ,103 ,215 ,19 ,163 ,229 ,229 ,20 ,50 ,162 ,17 ,133 ,124 ,249 ,169 ,12 ,5 ,149 ,167 ,84 ,31 ,131 ,239 ,213 ,210 ,184 ,39 ,213 ,171 ,100 ,60 ,11 ,224 ,232 ,78 ,195 ,151 ,174 ,143 ,45 ,147 ,29 ,211 ,227 ,244 ,168 ,60 ,1 ,192 ,184 ,216 ,55 ,224 ,244 ,142 ,47 ,34 ,137 ,3 ,73 ,227 ,215 ,121 ,56 ,231 ,228 ,177 ,116 ,202 ,235 ,63 ,91 ,59 ,221 ,243 ,161 ,133 ,131 ,29 ,53 ,95 ,65 ,192 ,219 ,22 ,127 ,237 ,199 ,27 ,159 ,241 ,185 ,15 ,49 ,0 ,173 ,120 ,243 ,53 ,90 ,16 ,180 ,82 ,230 ,222 ,174 ,162 ,221 ,144 ,27 ,224 ,194 ,182 ,53 ,32 ,53 ,168 ,237 ,218 ,127 ,6 ,149 ,222 ,233 ,189 ,187 ,220 ,247 ,163 ,187 ,117 ,92 ,87 ,159 ,29 ,36 ,51 ,16 ,116 ,80 ,240 ,4 ,169 ,253 ,215 ,128 ,119 ,241 ,36 ,239 ,110 ,188 ,104 ,107 ,231 ,91 ,234 ,115 ,24 ,64 ,68 ,112 ,206 ,249 ,152 ,193 ,249 ,71 ,32 ,107 ,63 ,23 ,161 ,153 ,82 ,177 ,127 ,4 ,176 ,75 ,92 ,141 ,97 ,60 ,252 ,24 ,227 ,167 ,111 ,103 ,228 ,231 ,238 ,248 ,95 ,250 ,93 ,209 ,45 ,238 ,100 ,21 ,76 ,177 ,27 ,103 ,200 ,194 ,148 ,7 ,137 ,190 ,54 ,168 ,237 ,98 ,29 ,24 ,107 ,208 ,157 ,153 ,118 ,87 ,28 ,159 ,42 ,13 ,19 ,148 ,220 ,236 ,89 ,156 ,175 ,23 ,6 ,192 ,207 ,247 ,238 ,82 ,49 ,139 ,80 ,224 ,17 ,51 ,7 ,59 ,174 ,73 ,86 ,50 ,10 ,150 ,116 ,88 ,36 ,87 ,30 ,136 ,110 ,43 ,236 ,128 ,8 ,125 ,195 ,144 ,211 ,0 ,92 ,157 ,17 ,21 ,142 ,66 ,245 ,234 ,133 ,4 ,23 ,193 ,98 ,214 ,156 )
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fresnostate/Downloads/audio_classic.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key_1
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: '64'
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: size//4
    input_size: size
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: 64//4
    equalizer: header_equalizer.base()
    fft_len: '64'
    fixed_frame_len: '1'
    len_tag_key: length_tag_key_1
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: 64//4
    equalizer: payload_equalizer.base()
    fft_len: '64'
    len_tag_key: length_tag_key_1
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: '64'
    len_tag_key: length_tag_key_1
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: '64'
    len_tag_key: length_tag_key_1
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Hermitian Transform',   # will show up in GRC\n            in_sig=[(np.complex64, 64)],\n            out_sig=[(np.complex64, 128)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n\n        out = []\n        for v in input_items[0]:\n            v2 = v[1:]\n            c = np.conj(v2)[::-1]\n            c2 = np.insert(c,0,0)\n            v3 = np.insert(v2,0,0)\n            o = np.concatenate( (v3, c2 ) )\n            out.append( o )     \n        output_items[0][:] = out\n        return len(output_items[0])\n \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Header Inverse Hermitian Transform',   # will show up in GRC\n            in_sig=[(np.complex64, 128)],\n            out_sig=[(np.complex64, 64)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.set_tag_propagation_policy(gr.TPP_DONT)\n        self.count = 0\n\n    def work(self, input_items, output_items):\n        tags = self.get_tags_in_window(0, 0, len(input_items[0]), pmt.intern(\"packet_len\"))\n        #for tag in tags:\n            #self.add_item_tag(0, tag.offset + self.nitems_written(0), tag.key, pmt.intern(str(960)))\n            #self.add_item_tag(0, tag.offset + self.nitems_written(0) + 3, tag.key, pmt.intern(str(960)))\n           # if self.count < 3:\n            #    self.count += 1\n             #   print(\"nitems_written \",self.nitems_written(0))\n             #   print(\"\\n\\n\", input_items[0] )\n             #   print(tag.offset)\n        out = []\n        for v in input_items[0]:\n            o = v[0:64]\n            out.append( o )     \n        output_items[0][:] = out\n        return len(output_items[0])\n        \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Payload Inverse Hermitian Transform',   # will show up in GRC
                  in_sig=[(np.complex64, 128)],
                  out_sig=[(np.complex64, 64)]
              )

              #self.set_tag_propagation_policy(gr.TPP_DONT)
              #self.count = 0

          def work(self, input_items, output_items):
              tags = self.get_tags_in_window(0, 0, len(input_items[0]), pmt.intern("packet_len"))
              for tag in tags:
                  self.add_item_tag(0, 9*tag.offset + self.nitems_written(0), tag.key, pmt.from_long(9))
                  self.add_item_tag(0, 9*tag.offset + self.nitems_written(0) + 9, tag.key, pmt.from_long(9))
                  self.add_item_tag(0, 9*tag.offset + self.nitems_written(0) + 18, tag.key, pmt.from_long(9))
                  self.add_item_tag(0, 9*tag.offset + self.nitems_written(0) + 27, tag.key, pmt.from_long(9))
             # if self.count < 5:
            #      self.count += 1
             #     print(len(input_items[0]))
                      
                #      print("nitems_written ",self.nitems_written(0))
                 #     print("\n\n", input_items[0] )
                #      print(tag.offset)
                
              out = []
              for v in input_items[0]:
                  o = v[0:64]
                  out.append( o )     
              output_items[0][:] = out
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (0,0,1,1)
    name: '"Time Domain"'
    plotconst: 'False'
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (1,0,1,1)
    size: size
    srate: '16'
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (3,0,1,1)
    name: '"Tagged Stream Mux"'
    size: size
    srate: '16'
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Post-FFT"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Post-Hermitian"'
    size: 1024*2
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Equalizer"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Serializer"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Payload Stream"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Header Stream"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_2
  id: qtgui_time_sink_x
  parameters:
    name: '"History"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Multiply"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Original Header Bits"'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Header Stream Bits"'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"CRC"'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Receiver Side
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Receiver Side
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_char_to_float_0, '0', blocks_throttle_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_2_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_char_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', header_bits, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle_0_0, '0', audio_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_time_sink_x_1_2, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_vector_to_stream_0_2_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [channels_channel_model_0, '0', blocks_delay_0, '0']
- [channels_channel_model_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_2, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_tagged_stream_mux_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_char_to_float_0_1, '0']
- [digital_crc32_bb_0_0, '0', blocks_vector_to_stream_2, '0']
- [digital_header_payload_demux_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0, '0']
- [digital_header_payload_demux_0, '1', blocks_vector_to_stream_0_0, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', epy_block_0, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_1, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', blocks_vector_to_stream_0_2_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [epy_block_0, '0', fft_vxx_0, '0']
- [epy_block_0_0_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [epy_block_0_0_0_0, '0', blocks_vector_to_stream_0_2, '0']
- [epy_block_0_0_0_0, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', epy_block_0_0_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_1, '0', epy_block_0_0_0_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_1, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_0_1, '0', fft_vxx_0_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', blocks_vector_to_stream_0_1, '0']
- [virtual_source_1_0, '0', fft_vxx_1, '0']

metadata:
  file_format: 1
