options:
  parameters:
    author: Vahae Ohanian (VahaeO@mail.fresnostate.edu), Jordan DiViccaro (Jordan1@mail.fresnostate.edu), HaoYuan "James" Wu (Jameswu91@mail.fresnostate.edu), Gregory Dzhezyan (Gregorydz@mail.fresnostate.edu), California State University-Fresno
    generate_options: qt_gui
    id: OFDM_Point_to_Point
    output_language: python
    title: OFDM_Point-to-Point
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[1+1j,-1+1j,1-1j,-1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '100'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: OFDM_Point_to_Point_Output_Text.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: File_A
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '100'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '1023'
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: size
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1023'
    type: complex
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: sample_WAV_48kHz.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+1j,-1+1j,1-1j,-1-1j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Inverse Hermitian Transform 2',   # will show up in GRC\n            in_sig=[(np.complex64, 2048)],\n            out_sig=[(np.complex64, 1023)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \n        out = []\n        for v in input_items[0]:\n            o = v[1:1024]\n            out.append( o )     \n        output_items[0][:] = out\n        return len(output_items[0])\n        \n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Hermitian Transform',   # will show up in GRC\n            in_sig=[(np.complex64, 1023)],\n            out_sig=[(np.complex64, 2048)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        out = []\n        for v in input_items[0]:\n            c = np.conj(v)[::-1]\n            c2 = np.insert(c,0,0)\n            v2 = np.insert(v,0,0)\n            o = np.concatenate( (v2, c2 ) )\n            out.append( o )     \n        output_items[0][:] = out\n        return len(output_items[0])\n        \n"
    example_param: '1.0'
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(size)
  states: {}
- name: note_0
  id: note
  parameters:
    note: Option of using either text or audio input. Please enable the appropriate input and output block.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: in1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: in2
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: in4
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: in1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: in2
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: in4
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_throttle_1_0, '0']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_float_to_char_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1, '0', virtual_sink_0, '0']
- [blocks_throttle_1_0, '0', audio_sink_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', virtual_sink_1, '0']
- [blocks_vector_to_stream_1, '0', virtual_sink_3, '0']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_char_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_vector_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [epy_block_0_0_1, '0', blocks_vector_to_stream_1, '0']
- [epy_block_0_1, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0_1, '0', epy_block_0_0_1, '0']
- [virtual_source_0, '0', epy_block_0_1, '0']
- [virtual_source_1, '0', blocks_complex_to_real_0, '0']
- [virtual_source_4, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
