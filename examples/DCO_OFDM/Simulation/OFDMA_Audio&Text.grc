options:
  parameters:
    author: Vahae Ohanian (VahaeO@mail.fresnostate.edu), Jordan DiViccaro (Jordan1@mail.fresnostate.edu), HaoYuan "James" Wu (Jameswu91@mail.fresnostate.edu), Gregory Dzhezyan (Gregorydz@mail.fresnostate.edu), California State University-Fresno
    generate_options: qt_gui
    id: OFDMA_Audio_and_Text
    output_language: python
    title: OFDMA_Audio&Text
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers_audio
  id: variable
  parameters:
    value: ((-4,-3,-2),)
  states: {}
- name: occupied_carriers_input
  id: variable
  parameters:
    value: ((-7,-6,-5,-4,-3,-2),)
  states: {}
- name: occupied_carriers_text
  id: variable
  parameters:
    value: ((-7,-6,-5),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '6'
  states: {}
- name: payload_mod_1
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[1+1j,-1+1j,1-1j,-1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '100'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: OFDMA_Output_Text.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: File_A
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '100'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod_1.bits_per_symbol()
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod_1.bits_per_symbol()
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod_1.bits_per_symbol()
    l: '8'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod_1.bits_per_symbol()
    l: '8'
    len_tag_key: ''
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (3,3)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: sample_WAV_48kHz.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod_1.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod_1.points()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod_1.base()
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod_1.base()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers_input
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: ()
  states: {}
- name: digital_ofdm_serializer_vcc_0
  id: digital_ofdm_serializer_vcc
  parameters:
    fft_len: fft_len
    occupied_carriers: occupied_carriers_text
  states: {}
- name: digital_ofdm_serializer_vcc_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    fft_len: fft_len
    occupied_carriers: occupied_carriers_audio
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_len)
  states: {}
- name: owc_Hermitian_Symmetry_i_o_same_vec_size_0
  id: owc_Hermitian_Symmetry_i_o_same_vec_size
  parameters:
    fft_len: fft_len
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    name: DCO-OFDM Signal
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    legend: 'False'
    name: Text Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: dco_ofdm_signal
  states: {}
- name: virtual_sink_1_0_1
  id: virtual_sink
  parameters:
    stream_id: demodulated_stream_text
  states: {}
- name: virtual_sink_1_0_1_0
  id: virtual_sink
  parameters:
    stream_id: demodulated_stream_audio
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: dco_ofdm_signal
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: demodulated_stream_audio
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: demodulated_stream_text
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_throttle_1_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_float_to_char_0_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', virtual_sink_1_0_1, '0']
- [blocks_repack_bits_bb_0_0_0_0, '0', virtual_sink_1_0_1_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_1_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_1_0, '0']
- [blocks_tag_gate_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_tag_gate_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_1_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_vector_to_stream_0_0_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_vector_to_stream_0_0_1, '0', virtual_sink_1_0_0, '0']
- [blocks_wavfile_source_0_0_0, '0', blocks_float_to_char_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_stream_mux_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0, '0', blocks_stream_mux_0_0, '1']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', owc_Hermitian_Symmetry_i_o_same_vec_size_0, '0']
- [digital_ofdm_serializer_vcc_0, '0', digital_constellation_decoder_cb_1, '0']
- [digital_ofdm_serializer_vcc_0_0, '0', digital_constellation_decoder_cb_1_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0_1, '0']
- [fft_vxx_0_1_0, '0', digital_ofdm_serializer_vcc_0, '0']
- [fft_vxx_0_1_0, '0', digital_ofdm_serializer_vcc_0_0, '0']
- [owc_Hermitian_Symmetry_i_o_same_vec_size_0, '0', fft_vxx_0_0, '0']
- [virtual_source_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_1_0, '0', blocks_complex_to_real_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_1_0_0_0, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
