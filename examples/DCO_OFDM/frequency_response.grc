options:
  parameters:
    author: arsalan
    generate_options: hb
    id: LED_frequency_response
    output_language: python
    title: LED Frequency Response
  states: {}

blocks:
- name: cut_off_frequency_HP
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: cut_off_frequency_LP
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (2.5e6)
  states: {}
- name: taps_HP
  id: variable_high_pass_filter_taps
  parameters:
    cutoff_freq: cut_off_frequency_HP
    gain: '1.0'
    samp_rate: samp_rate
    width: transition_width_HP
    win: firdes.WIN_HAMMING
  states: {}
- name: taps_LP
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut_off_frequency_LP
    gain: '1.0'
    samp_rate: samp_rate
    width: transition_width_LP
    win: firdes.WIN_HAMMING
  states: {}
- name: transition_width_HP
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: transition_width_LP
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: taps_LP
    type: fff
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: taps_HP
    type: fff
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', fft_filter_xxx_1, '0']
- [fft_filter_xxx_1, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
