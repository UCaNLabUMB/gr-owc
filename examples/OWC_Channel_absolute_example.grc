options:
  parameters:
    author: Arsalan Ahmed
    generate_options: qt_gui
    id: OWC_Channel_absolute_Example
    output_language: python
    title: Example of the absolute channel model
  states: {}

blocks:
- name: rx_A_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_A_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_C_r_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_C_r_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_psi_c_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: rx_psi_c_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: rx_u_x_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_x_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_y_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_y_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: rx_u_z_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '-1'
  states: {}
- name: rx_u_z_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '-1'
  states: {}
- name: rx_x_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rx_x_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: rx_y_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rx_y_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rx_z_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: rx_z_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: tx_C_t_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_C_t_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_m_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_m_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_u_x_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_x_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_y_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_y_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: tx_u_z_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: tx_u_z_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: tx_x_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_x_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: tx_y_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_y_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_z_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: tx_z_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: tx_y_1
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: tx_x_1
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: tx_x_2
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: rx_x_2
    type: float
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: rx_x_1
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: tx_y_2
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: rx_y_2
    type: float
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: rx_y_1
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-4'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: Setting a non-zero noise-floor to remove inaccuracies
  states: {}
- name: owc_OWC_Channel_absolute_0
  id: owc_OWC_Channel_absolute
  parameters:
    E2O_conversion_factor_array: '[tx_C_t_1, tx_C_t_2]'
    O2E_conversion_factor_array: '[rx_C_r_1, rx_C_r_2]'
    concentrator_FOV_array: '[rx_psi_c_1, rx_psi_c_2]'
    num_inputs: '2'
    num_outputs: '2'
    optical_filter_transmittance_array: '[rx_Ts_1, rx_Ts_2]'
    refractive_index_array: '[rx_n_1, rx_n_2]'
    rx_coordinates_array: '[rx_x_1, rx_y_1, rx_z_1 , rx_x_2, rx_y_2, rx_z_2]'
    rx_orientation_array: '[rx_u_x_1, rx_u_y_1, rx_u_z_1 , rx_u_x_2, rx_u_y_2, rx_u_z_2]'
    rx_photosensor_area_array: '[rx_A_1, rx_A_2]'
    tx_coordinates_array: '[tx_x_1, tx_y_1, tx_z_1 , tx_x_2, tx_y_2, tx_z_2]'
    tx_lambertian_order_array: '[tx_m_1, tx_m_2]'
    tx_orientation_array: '[tx_u_x_1, tx_u_y_1, tx_u_z_1 , tx_u_x_2, tx_u_y_2, tx_u_z_2]'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Tx XY location coordinates"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '10'
    xmin: '-10'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    color2: '"black"'
    name: '"Rx XY location coordinates"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '10'
    xmin: '-10'
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Rx 1 Frequency Domain"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"yellow"'
    fc: '0'
    fftsize: '1024'
    name: '"Rx 2 Frequency Domain"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx 2"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    name: '"Tx 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    name: '"Tx 2"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_const_source_x_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0, '0']
- [analog_const_source_x_0_0_1, '0', blocks_float_to_complex_0_0_0, '0']
- [analog_const_source_x_0_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_1_0, '0', blocks_float_to_complex_0_0_0_0, '1']
- [analog_const_source_x_0_2, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', owc_OWC_Channel_absolute_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_float_to_complex_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_float_to_complex_0_0_0_0, '0', qtgui_const_sink_x_0_0, '1']
- [blocks_throttle_0, '0', owc_OWC_Channel_absolute_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [owc_OWC_Channel_absolute_0, '0', blocks_add_xx_0, '1']
- [owc_OWC_Channel_absolute_0, '1', blocks_add_xx_0_0, '1']

metadata:
  file_format: 1
