options:
  parameters:
    author: Arsalan Ahmed
    generate_options: qt_gui
    id: OWC_Channel_relative_Mod_Example
    output_language: python
    title: Example of the relative channel model with Modulators
  states: {}

blocks:
- name: d_1_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: d_1_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: d_2_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: d_2_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: m_1_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: max_magnitude_tx1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: max_magnitude_tx2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: min_magnitude_tx1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: min_magnitude_tx2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: modulation_order_tx2
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rx_A_1
  id: variable
  parameters:
    value: '1e-6'
  states: {}
- name: rx_A_2
  id: variable
  parameters:
    value: '1e-6'
  states: {}
- name: rx_C_r_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_C_r_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_Ts_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_n_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_psi_1_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rx_psi_1_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: rx_psi_2_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: rx_psi_2_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rx_psi_c_1
  id: variable
  parameters:
    value: '90'
  states: {}
- name: rx_psi_c_2
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samples_per_symbol_tx1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samples_per_symbol_tx2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: tx_C_t_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_C_t_2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_m_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: tx_m_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: tx_phi_1_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: tx_phi_1_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: tx_phi_2_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: tx_phi_2_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '32'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '32'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: owc_OOK_Modulator_one_0
  id: owc_OOK_Modulator_one
  parameters:
    max_mag: max_magnitude_tx1
    min_mag: min_magnitude_tx1
    samples_per_symbol: samples_per_symbol_tx1
  states: {}
- name: owc_OWC_Channel_relative_0
  id: owc_OWC_Channel_relative
  parameters:
    E2O_conversion_factor_array: '[tx_C_t_1, tx_C_t_2]'
    O2E_conversion_factor_array: '[rx_C_r_1, rx_C_r_2]'
    acceptance_angle_array: '[rx_psi_1_1, rx_psi_1_2, rx_psi_2_1, rx_psi_2_2]'
    concentrator_FOV_array: '[rx_psi_c_1, rx_psi_c_2]'
    distance_array: '[d_1_1, d_1_2, d_2_1, d_2_2]'
    emission_angle_array: '[tx_phi_1_1, tx_phi_1_2, tx_phi_2_1, tx_phi_2_2]'
    lambertian_order_array: '[tx_m_1, tx_m_2]'
    num_inputs: '2'
    num_outputs: '2'
    optical_filter_transmittance_array: '[rx_Ts_1, rx_Ts_2]'
    photosensor_area_array: '[rx_A_1, rx_A_2]'
    refractive_index_array: '[rx_n_1, rx_n_2]'
  states: {}
- name: owc_PAM_Modulator_one_0
  id: owc_PAM_Modulator_one
  parameters:
    max_mag: max_magnitude_tx2
    min_mag: min_magnitude_tx2
    mod_order: modulation_order_tx2
    samples_per_symbol: samples_per_symbol_tx2
  states: {}
- name: owc_binary_to_decimal_mapper_0
  id: owc_binary_to_decimal_mapper
  parameters:
    mod_order: modulation_order_tx2
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    name: '"Rx 1 Time Domain"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: magenta
    name: '"Rx 2 Time Domain"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    name: '"Tx 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    name: '"Tx 2"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_random_source_x_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_throttle_0, '0', owc_OWC_Channel_relative_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_1, '0', owc_OOK_Modulator_one_0, '0']
- [blocks_uchar_to_float_1_0, '0', owc_binary_to_decimal_mapper_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_1_0, '0']
- [owc_OOK_Modulator_one_0, '0', blocks_throttle_0, '0']
- [owc_OWC_Channel_relative_0, '0', qtgui_time_sink_x_0, '0']
- [owc_OWC_Channel_relative_0, '1', qtgui_time_sink_x_0_0, '0']
- [owc_PAM_Modulator_one_0, '0', owc_OWC_Channel_relative_0, '1']
- [owc_PAM_Modulator_one_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [owc_binary_to_decimal_mapper_0, '0', owc_PAM_Modulator_one_0, '0']

metadata:
  file_format: 1
